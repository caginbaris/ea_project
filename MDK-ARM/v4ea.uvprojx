# Keil uVision project v4ea.uvprojx, settings and files
target v4ea (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F373R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: v4ea
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F373xC, ARM_MATH_CM4,__FPU_PRESENT
  c include: ../Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;  ../Drivers/CMSIS/Include;  ..\header_files
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ./: startup_stm32f373xc.s
  group conversion
    ./: converison.c prefilter.c phaseCompensation.c
  group LCD_driver
    ./: LCD_routines.c LCD_data.c LCD_fonts.c
  group Application/User
    ../Src/: adc.c main.c tim.c stm32f3xx_it.c stm32f3xx_hal_msp.c usart.c sdadc.c gpio.c spi.c rtc.c dma.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_spi.c stm32f3xx_hal_uart.c stm32f3xx_hal.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_tim.c stm32f3xx_hal_adc.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f3xx.c
  group MENU_handles
    ./: Menu_routines.c Menu_data.c Menu_init.c
  group measurement
    ./: measurement_data.c measurement_functions.c measurement_routines.c
  group push_buttons
    ./: pb_handling.c
  group aux_functions
    ./: aux_functions.c
  group graphing
    ./: graphing_fuctions.c
  group flashDataHandling
    ./: flashDataHandling.c
  group ios
    ./: ios.c
  group record
    ./: record.c
  group comm
    ./: Modbus_RTU_Slave.c
